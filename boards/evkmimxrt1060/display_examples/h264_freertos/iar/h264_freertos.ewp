# IAR project h264_freertos.ewp, settings and files
configuration flexspi_nor_sdram_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SDK_OS_FREE_RTOS; __NXP_MSDK__; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pe815,Pe111,Pe186,Pe068,Pe177
  ICCARM.IExtraOptions: --diag_suppress Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../rtos/freertos/libraries/abstractions/posix/include; ../../../../../rtos/freertos/libraries/freertos_plus/standard/freertos_plus_posix/include; ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private; ../../../../../components/video/display/dc/elcdif; ../../../../../devices/MIMXRT1062/drivers; ../../../../../devices/MIMXRT1062/utilities/debug_console_lite; ../../../../../components/gpio; ../../../../../middleware/sdmmc/sd; ../../../../../middleware/sdmmc/common; ../../../../../middleware/sdmmc/host/usdhc; ../../../../../middleware/fatfs/source; ../../../../../middleware/fatfs/source/fsl_sd_disk; ../../../../../components/video/display/fbdev; ../../../../../components/video; ../../../../../middleware/openh264/codec/decoder/core/inc; ../../../../../middleware/openh264/codec/decoder/plus/inc; ../../../../../devices/MIMXRT1062; ../../../../../components/uart; ../../../../../components/lists; ../../../../../devices/MIMXRT1062/xip; ../../../xip; ../../../../../components/silicon_id; ../../../../../components/video/display/dc; ../../../../../CMSIS/Core/Include; ../../../../../middleware/sdmmc/osa; ../../../../../components/osa; ../../../../../rtos/freertos/freertos_kernel/include; ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F; ../../../../../middleware/openh264/codec/api/svc; ../../../../../middleware/openh264/codec/common/inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..
  ILINK.IlinkOutputFile: h264_freertos.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1800000
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_flexspi_nor_sdram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flexspi_nor_sdram_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; NDEBUG; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SDK_OS_FREE_RTOS; __NXP_MSDK__; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration sdram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=0; XIP_BOOT_HEADER_ENABLE=0; XIP_BOOT_HEADER_DCD_ENABLE=1; SKIP_SYSCLK_INIT; DATA_SECTION_IS_CACHEABLE=1; CPU_MIMXRT1062DVL6A; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; SD_ENABLED; SDK_OS_FREE_RTOS; __NXP_MSDK__; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_sdram.icf
configuration opt_mix_ram_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ILINK.IlinkIcfFile: MIMXRT1062xxxxx_opt_mix_ram.icf
  group board
    ../: board.c board.h clock_config.c clock_config.h dcd.c dcd.h display_support.c display_support.h pin_mux.c pin_mux.h sdmmc_config.c sdmmc_config.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm7.h mpu_armv7.h
  group component/gpio
    ../../../../../components/gpio/: fsl_adapter_gpio.h fsl_adapter_igpio.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_config.h fsl_os_abstraction_free_rtos.c fsl_os_abstraction_free_rtos.h
  group component/silicon_id
    ../../../../../components/silicon_id/: fsl_silicon_id.c fsl_silicon_id.h
  group component/uart
    ../../../../../components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    ../../../../../devices/MIMXRT1062/: fsl_device_registers.h MIMXRT1062.h MIMXRT1062_features.h system_MIMXRT1062.c system_MIMXRT1062.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../devices/MIMXRT1062/drivers/: fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_elcdif.c fsl_elcdif.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_pxp.c fsl_pxp.h fsl_usdhc.c fsl_usdhc.h
  group fatfs/source
    ../../../../../middleware/fatfs/source/: diskio.c diskio.h ff.c ff.h ffsystem.c ffunicode.c
  group fatfs/source/fsl_sd_disk
    ../../../../../middleware/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group freertos/freertos_kernel
    ../../../../../rtos/freertos/freertos_kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos_kernel/include
    ../../../../../rtos/freertos/freertos_kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos_kernel/portable
    ../../../../../rtos/freertos/freertos_kernel/portable/: readme.txt
  group freertos/freertos_kernel/portable/IAR/ARM_CM4F
    ../../../../../rtos/freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group freertos/freertos_kernel/portable/MemMang
    ../../../../../rtos/freertos/freertos_kernel/portable/MemMang/: heap_4.c ReadMe.url
  group freertos/libraries/abstractions/posix/include/FreeRTOS_POSIX
    ../../../../../rtos/freertos/libraries/abstractions/posix/include/FreeRTOS_POSIX/: errno.h fcntl.h mqueue.h pthread.h sched.h semaphore.h signal.h time.h unistd.h utils.h
  group freertos/libraries/abstractions/posix/include/FreeRTOS_POSIX/sys
    ../../../../../rtos/freertos/libraries/abstractions/posix/include/FreeRTOS_POSIX/sys/: types.h
  group freertos/libraries/c_sdk/standard/common/include/private
    ../../../../../rtos/freertos/libraries/c_sdk/standard/common/include/private/: iot_doubly_linked_list.h
  group freertos/libraries/freertos_plus/standard/freertos_plus_posix/include
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/freertos_plus_posix/include/: FreeRTOS_POSIX.h FreeRTOS_POSIX_internal.h FreeRTOS_POSIX_portable_default.h FreeRTOS_POSIX_types.h
  group freertos/libraries/freertos_plus/standard/freertos_plus_posix/source
    ../../../../../rtos/freertos/libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group openh264/codec/api/svc
    ../../../../../middleware/openh264/codec/api/svc/: codec_api.h codec_app_def.h codec_def.h codec_ver.h
  group openh264/codec/common/inc
    ../../../../../middleware/openh264/codec/common/inc/: asmdefs_mmi.h copy_mb.h cpu.h cpu_core.h crt_util_safe_x.h deblocking_common.h expand_pic.h golomb_common.h intra_pred_common.h ls_defines.h macros.h mc.h measure_time.h memory_align.h sad_common.h typedefs.h utils.h version.h wels_common_defs.h wels_const_common.h welsCodecTrace.h WelsList.h WelsLock.h WelsTask.h WelsTaskThread.h WelsThread.h WelsThreadLib.h WelsThreadPool.h
  group openh264/codec/common/src
    ../../../../../middleware/openh264/codec/common/src/: common_tables.cpp copy_mb.cpp cpu.cpp crt_util_safe_x.cpp deblocking_common.cpp expand_pic.cpp intra_pred_common.cpp mc.cpp memory_align.cpp sad_common.cpp utils.cpp welsCodecTrace.cpp WelsTaskThread.cpp WelsThread.cpp WelsThreadLib.cpp WelsThreadPool.cpp
  group openh264/codec/decoder/core/inc
    ../../../../../middleware/openh264/codec/decoder/core/inc/: au_parser.h bit_stream.h cabac_decoder.h deblocking.h dec_frame.h dec_golomb.h decode_mb_aux.h decode_slice.h decoder.h decoder_context.h decoder_core.h error_code.h error_concealment.h fmo.h get_intra_predictor.h manage_dec_ref.h mb_cache.h memmgr_nal_unit.h mv_pred.h nal_prefix.h nalu.h parameter_sets.h parse_mb_syn_cabac.h parse_mb_syn_cavlc.h pic_queue.h picture.h rec_mb.h slice.h vlc_decoder.h wels_common_basis.h wels_const.h wels_decoder_thread.h
  group openh264/codec/decoder/core/src
    ../../../../../middleware/openh264/codec/decoder/core/src/: au_parser.cpp bit_stream.cpp cabac_decoder.cpp deblocking.cpp decode_mb_aux.cpp decode_slice.cpp decoder.cpp decoder_core.cpp decoder_data_tables.cpp error_concealment.cpp fmo.cpp get_intra_predictor.cpp manage_dec_ref.cpp memmgr_nal_unit.cpp mv_pred.cpp parse_mb_syn_cabac.cpp parse_mb_syn_cavlc.cpp pic_queue.cpp rec_mb.cpp wels_decoder_thread.cpp
  group openh264/codec/decoder/plus/inc
    ../../../../../middleware/openh264/codec/decoder/plus/inc/: welsDecoderExt.h
  group openh264/codec/decoder/plus/src
    ../../../../../middleware/openh264/codec/decoder/plus/src/: welsDecoderExt.cpp
  group sdmmc/host
    ../../../../../middleware/sdmmc/host/usdhc/: ChangeLogKSDK.txt fsl_sdmmc_host.h
    ../../../../../middleware/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
  group sdmmc/inc
    ../../../../../middleware/sdmmc/sd/: fsl_sd.h
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.h fsl_sdmmc_spec.h
  group sdmmc/osa
    ../../../../../middleware/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
  group sdmmc/sd
    ../../../../../middleware/sdmmc/sd/: ChangeLogKSDK.txt
  group sdmmc/src
    ../../../../../middleware/sdmmc/sd/: fsl_sd.c
    ../../../../../middleware/sdmmc/common/: fsl_sdmmc_common.c
  group source
    ../: display.c display.h ffconf.h FreeRTOS_POSIX_portable.h FreeRTOSConfig.h h264_dec.cpp h264_dec.h h264_freertos.c sdcard.c sdcard.h
  group startup
    ../../../../../devices/MIMXRT1062/iar/: startup_MIMXRT1062.s
  group utilities
    ../../../../../devices/MIMXRT1062/utilities/debug_console_lite/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h
  group video
    ../../../../../components/video/display/dc/: fsl_dc_fb.h
    ../../../../../components/video/display/dc/elcdif/: fsl_dc_fb_elcdif.c fsl_dc_fb_elcdif.h
    ../../../../../components/video/display/fbdev/: fsl_fbdev.c fsl_fbdev.h
    ../../../../../components/video/: fsl_video_common.c fsl_video_common.h
  group xip
    ../../../xip/: evkmimxrt1060_flexspi_nor_config.c evkmimxrt1060_flexspi_nor_config.h
    ../../../../../devices/MIMXRT1062/xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
